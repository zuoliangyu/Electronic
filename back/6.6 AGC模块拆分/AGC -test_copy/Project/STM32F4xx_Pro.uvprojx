# Keil uVision project STM32F4xx_Pro.uvprojx, settings and files
target STM32F4xx_Pro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\BSP\Inc;..\Core;..\Debug\Inc;..\FWLIB\inc;..\System\Inc;..\User\Inc;..\FatFs\src;..\FatFs\exFiles;..\APP;..\AUDIOCODEC;..\USMART;..\MYFANC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/Src/: main.c
  group BSP
    ../BSP/Src/: clk.c key.c led.c SPI.C w25qxx.c i2c.c 24Cxx.c fsmc.c adc.c
    ../User/Src/: malloc.c
  group System
    ../System/Src/: delay.c sys.c system_stm32f4xx.c stm32f4xx_it.c
  group Debug
    ../Debug/Src/: error.c usart1.c usart2.c assert.c
  group Core
    ../Core/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c
  group MYFANC
    ../MYFANC/Src/: frequency.c HMI_test.c vpp_test.c
